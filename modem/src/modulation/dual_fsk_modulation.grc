<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dual_fsk_modulation</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SPS</value></param>
<param><key>value</key><value>samp_rate/baud</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>300/oversample</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>comment</key><value>Frequency deviation of 
GFSK modulation</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversample</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>lo_delay * SPS</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>input_path_hi</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>input_path_lo</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>comment</key><value>Establish number of
samples per symbol</value></param>
<param><key>interp</key><value>SPS</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>comment</key><value>Establish number of
samples per symbol</value></param>
<param><key>interp</key><value>SPS</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_f</key>
<param><key>id</key><value>blocks_vco_f_0</value></param>
<param><key>amplitude</key><value>0.25</value></param>
<param><key>comment</key><value>FSK modulation</value></param>
<param><key>samp_rate</key><value>samp_rate*oversample</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>blocks_vco_f</key>
<param><key>id</key><value>blocks_vco_f_0_0</value></param>
<param><key>amplitude</key><value>0.25</value></param>
<param><key>comment</key><value>FSK modulation</value></param>
<param><key>samp_rate</key><value>samp_rate*oversample</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>/tmp/data.wav</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier_freq_hi</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1750</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier_freq_lo</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1080</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>comment</key><value>Binary 1's and 0's to symbols.</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>(2*3.14*carrier_freq_hi-2*3.14*fsk_deviation_hz,2*3.14*carrier_freq_hi+2*3.14*fsk_deviation_hz)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>comment</key><value>Binary 1's and 0's to symbols.</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>(2*3.14*carrier_freq_lo-2*3.14*fsk_deviation_hz,2*3.14*carrier_freq_lo+2*3.14*fsk_deviation_hz)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_path_hi</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/remote.bin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_path_lo</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/local.bin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_delay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>180</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_vco_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>blocks_vco_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_f_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_f_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
